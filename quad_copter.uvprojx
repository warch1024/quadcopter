# Keil uVision project quad_copter.uvprojx, settings and files
target quad_copter (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: quad_copter +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F103xB
  c include: .\hard_ware;.\system;.\user;.\RTE;.\RTE\Device\STM32F103C8;.\freeRTOS;.\freeRTOS\include;.\freeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c
  group system
    ./system/: attitude.c attitude.h communication.c communication.h cascade_PID.c cascade_PID.h
  group hard_ware
    ./hard_ware/: MPU6050.c MPU6050.h VL53LXX.c VL53LXX.h NRF24L01.c NRF24L01.h M8520.c M8520.h uart.c uart.h electronic_speed_controller.h electronic_speed_controller.c
  group freeRTOS
    ./freeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c FreeRTOSConfig.h readme.txt
    ./freeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ./freeRTOS/portable/MemMang/: heap_4.c
  group freeRTOS/include
    ./freeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:CRC 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
