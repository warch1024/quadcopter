<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\VL53L1X_UltraLiteDriver.ewp</path>
  </project>
  <batchBuild />
</workspace>
